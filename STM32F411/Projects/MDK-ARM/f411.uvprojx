# Keil uVision project f411.uvprojx, settings and files
target f411 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Kato +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,DEBUG_MODE=1
  c include: ..\..\APP\inc;..\..\APP\src;..\..\BSP\src;..\..\BSP\inc;..\..\Config;..\..\System\Lib\inc;..\..\System\CMSIS\Include;..\..\System\STM32F4xx_HAL_Driver\Inc;..\..\System\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\System\CMSIS\Device\ST\STM32F4xx\Include;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../System/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f411xe.s
  group APP/src
    ../../APP/src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c freertos_tasks.c
  group BSP/src
    ../../BSP/src/: bsp_led.c bsp_usart1.c
  group Config
    ../../Config/: user_config.c FreeRTOSConfig.h stm32f4xx_hal_conf.h user_config.h
  group System/STM32F4xx_HAL_Driver
    ../../System/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group System/Lib
    ../../System/Lib/src/: sys.c bsp_timebase.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
